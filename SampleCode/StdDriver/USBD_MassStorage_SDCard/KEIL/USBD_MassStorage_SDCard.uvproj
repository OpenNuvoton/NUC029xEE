# Keil uVision project USBD_MassStorage_SDCard.uvproj, settings and files
target USBD_MassStorage_SDCard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC029SEE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_MassStorage_SDCard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029xEE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC029xEE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/: system_NUC029xEE.c
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/ARM/: startup_NUC029xEE.s
  group User
    ../: main.c descriptors.c MassStorage.c SDCard.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c usbd.c sys.c spi.c gpio.c
