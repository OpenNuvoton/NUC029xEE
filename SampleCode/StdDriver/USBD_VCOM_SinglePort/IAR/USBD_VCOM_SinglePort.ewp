# IAR project USBD_VCOM_SinglePort.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029EE series Nuvoton NUC029EE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xEE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_VCOM_SinglePort.bin
  ILINK.IlinkOutputFile: USBD_VCOM_SinglePort.out
  ILINK.IlinkIcfFile: USBD_VCOM_SinglePort.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/IAR/: startup_NUC029xEE.s
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/: system_NUC029xEE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c
  group User
    ../: cdc_serial.c descriptors.c main.c
