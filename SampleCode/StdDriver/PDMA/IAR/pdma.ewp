# IAR project pdma.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029EE series Nuvoton NUC029EE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xEE\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pdma.bin
  ILINK.IlinkOutputFile: pdma.out
  ILINK.IlinkIcfFile: pdma.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/IAR/: startup_NUC029xEE.s
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/: system_NUC029xEE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
