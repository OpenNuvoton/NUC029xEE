# IAR project FMC_IAP.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029EE series Nuvoton NUC029EE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xEE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_IAP.bin
  ILINK.IlinkOutputFile: FMC_IAP.out
  ILINK.IlinkIcfFile: FMC.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_IAP_LD.bin,loaderImageBase,.bin_image,4; --image_input Release\Exe\FMC_IAP_LD.bin,loaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/IAR/: startup_NUC029xEE.s
    ../../../../Library/Device/Nuvoton/NUC029xEE/Source/: system_NUC029xEE.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
